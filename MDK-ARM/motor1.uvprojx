# Keil uVision project motor1.uvprojx, settings and files
target motor1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: motor1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F750xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../supercar;../USMART;../USART;../TIME;../Calculate;../IMU;../BAR;../M294;../SNOW;../OPENMV;../QRCODE;../LSC;..\STACK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/User/Core
    ./: startup_stm32f750xx.s
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group supercar
    ../supercar/: wheel_config.c wheel_encode.c wheel_pwm.c wheel_task.c wheel.c journey.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group Calculate
    ../Calculate/: pid.c
  group TIME
    ../TIME/: time_cnt.c time_delay.c
  group IMU
    ../IMU/: imu.c imu_task.c
  group BAR
    ../BAR/: track_task.c bar.c
  group M294
    ../M294/: m294.c
  group SNOW
    ../SNOW/: snow.c turn_task.c
  group OPENMV
    ../OPENMV/: openmv.c
  group QRCODE
    ../QRCODE/: qrcode.c
  group LSC
    ../LSC/: lsc.c
  group STACk
    ../STACK/: stack_transfer.c
software components: CMSIS:CORE 4.3.0
